# Keil uVision project STM32F103C8T6.uvprojx, settings and files
target STM32F103C8T6 (6190000::V6.19::.\ArmCompilerforEmbedded6.19)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C8T6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 v6Lto=1 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32F103xB,_HDL_LIB,ULOG_ENABLED
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../HDL;../LIB;../CHIP;../APP;../BFL;../Board;..\third party\ulog;..\third party\u8g2;..\third party\SEGGER;..\third party\SimpleDPP;..\third party\cJSON;../test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/User/Core
    ../Core/Src/: dma.c main.c gpio.c adc.c can.c i2c.c iwdg.c rtc.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_spi.c stm32f1xx_hal_gpio_ex.c stm32f1xx_ll_gpio.c stm32f1xx_ll_adc.c stm32f1xx_ll_dma.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_ll_crc.c stm32f1xx_hal_i2c.c stm32f1xx_ll_rtc.c stm32f1xx_ll_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group APP
    ../APP/: APP_Main.c
  group Board
    ../Board/: Board.c Board_Fan.c
  group BFL
    ../BFL/: alarm_clock.c asyn_sys.c BFL_Buzz.c BFL_LED.c BFL_RS485.c cooperate_scheduler.c cooperate_scheduler_test.c Key.c modbus_host.c modbus_test.c mtime.c scheduler.c scheduler_test.c test_lib.c BFL_RS422.c BFL_RS485422.c
    ../BFL/if/: assert_if.c cpu_time.c log.c rtc_time.c
  group HDL
    ../HDL/: HDL_ADC.c HDL_CPU.c HDL_CPU_Time.c HDL_CPU_Time_test.c HDL_Flash.c HDL_Flash_test.c HDL_GPIO.c HDL_IIC.c HDL_PWM.c HDL_PWM_test.c HDL_RTC.c HDL_RTC_test.c HDL_SPI.c HDL_Uart.c HDL_Uart_test.c HDL_CAN.c HDL_Freq_Measure.c
  group LIB
    ../LIB/: bit_operation.c circular_array_queu.c circular_array_queu_test.c mytime.c ptr.c Queue.c sc_bitmap.c sc_byte_buffer.c sc_list.c str.c ulog.c PID.c crc.c pid_fp32.c
  group SEGGER
    ../third party/SEGGER/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group SimpleDPP
    ../third party/SimpleDPP/: ByteBuffer.c SimpleDPP.c
  group cJSON
    ../third party/cJSON/: cJSON.c cJSON_Utils.c
  group Test
    ../test/: Test.c
software components: CMSIS:CORE 6.1.0
